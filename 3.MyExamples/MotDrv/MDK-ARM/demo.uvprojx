# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Board;../Board/paratbl;../Board/modbus;../Libraries/modbus;../Libraries;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Board/: defs.h
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/Database
    ../Board/paratbl/: gconf.h paratbl.h paratbl.c
  group Drivers/Pinctrl
    ../Board/pinctrl/: dido.c key.c led.c
  group Drivers/System
    ../Board/system/: buildtime.c sleep.c sysrst.c
  group Drivers/Serial
    ../Board/serial/: bsp_uart.c retarget.c
  group Drivers/Screen
    ../Board/oled/: font.c font.h oled_i2c.c oled_i2c.h
  group Drivers/Sensor
    ../Board/sensor/: ntc.c vbus.c pot.c isen.c
  group Drivers/Motdrv/Foc
    ../Board/motdrv/foc/: foc.c pid.c pwmctrl.c cursamp.c
  group Drivers/Motdrv/Enc
    ../Board/motdrv/enc/: abs.c hall.c inc.c mag.c rot.c
  group Drivers/Motdrv/Filter
    ../Board/motdrv/filter/: rc.c rc.h
  group Libraries/Button/Core
    ../Libraries/button/: button.c
  group Libraries/Modbus/Core
    ../Libraries/modbus/: mb.c mbascii.c mbcrc.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbtcp.c mbutils.c
  group Libraries/Modbus/Port
    ../Board/modbus/: portcb.c portevent.c portserial.c porttimer.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
software components: CMSIS:CORE 5.5.0
