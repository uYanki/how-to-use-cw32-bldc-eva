# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32F030C8 WHXY
  pack: WHXY.CW32F030_DFP.1.0.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\code\inc;..\..\..\fwlib;..\..\..\fwlib\inc;..\..\..\board;..\..\..\libraries
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../code/src/: startup_cw32f030.s
  group user
    ../code/inc/: board_conf.h
    ../code/src/: interrupts_cw32f030.c main.c
  group board/bsp
    ../../../board/bsp/clk/: sysclk.c
    ../../../board/bsp/gpio/: key.c beep.c led.c
    ../../../board/bsp/adc/: ntc.c pot.c adc.c
    ../../../board/bsp/tim/: hallEnc.c pwm.c
    ../../../board/bsp/uart/: uart.c
  group board/sys
    ../../../board/sys/: sleep.c syscall.c
    ../../../board/foc/: step6.c
  group foc
    ../../../board/foc/: foc.c pid.c
  group fwlib
    ../../../fwlib/src/: cw32f030_adc.c cw32f030_atim.c cw32f030_awt.c cw32f030_btim.c cw32f030_crc.c cw32f030_debug.c cw32f030_digitalsign.c cw32f030_dma.c cw32f030_flash.c cw32f030_gpio.c cw32f030_gtim.c cw32f030_i2c.c cw32f030_iwdt.c cw32f030_lvd.c cw32f030_pwr.c cw32f030_ram.c cw32f030_rcc.c cw32f030_rtc.c cw32f030_spi.c cw32f030_systick.c cw32f030_uart.c cw32f030_vc.c cw32f030_wwdt.c system_cw32f030.c
software components: CMSIS:CORE 5.5.0
